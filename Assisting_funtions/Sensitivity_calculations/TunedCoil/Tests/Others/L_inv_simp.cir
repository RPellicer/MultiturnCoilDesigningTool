V1 0 1 Symbolic
L1 1 2 Symbolic
R1 2 3 Symbolic
C2 3 0 Symbolic
R2 3 0 Symbolic
