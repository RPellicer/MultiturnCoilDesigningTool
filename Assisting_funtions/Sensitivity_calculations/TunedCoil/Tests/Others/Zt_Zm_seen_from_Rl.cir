Vexc_no 0 1 Symbolic
Rs_no 1 2 Symbolic
Ls_no 2 3 Symbolic
Ct_no 0 3 Symbolic
