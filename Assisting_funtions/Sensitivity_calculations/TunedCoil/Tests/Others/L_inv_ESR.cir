V1 0 1 Symbolic
L 1 2 Symbolic
Rs_c1 2 3 Symbolic
C1 3 4 Symbolic
R_c2 4 5 Symbolic
C2 5 0 Symbolic
Ca 4 0 Symbolic
Ra 4 0 Symbolic
