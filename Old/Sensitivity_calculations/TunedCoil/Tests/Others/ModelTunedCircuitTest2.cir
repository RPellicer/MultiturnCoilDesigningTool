Vin 0 1 Symbolic
L1 1 2 20E-3
R1 2 3 70
C1 0 3 1e-9
C2 3 4 1e-6
R2 0 4 1e6
