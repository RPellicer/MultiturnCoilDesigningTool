Vin 0 1 Symbolic
L1 1 2 Symbolic
R1 2 3 Symbolic
C1 0 3 Symbolic
