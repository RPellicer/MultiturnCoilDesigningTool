V1 0 1 Symbolic
Ls_s 1 2 Symbolic
Rs_s 2 3 Symbolic
Ct1_s 3 4 Symbolic
Ct2_s 4 0 Symbolic
Ca_s 4 0 Symbolic
Ra_s 4 0 Symbolic
