Vin 0 1 Symbolic
L1 1 2 57.4e-3
R1 2 3 71.7
C1 0 3 8.2e-12
