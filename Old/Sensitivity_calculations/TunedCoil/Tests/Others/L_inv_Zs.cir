L 0 1 Symbolic
Rs 1 2 Symbolic
Cs 2 0 Symbolic
V1 2 0 Symbolic
