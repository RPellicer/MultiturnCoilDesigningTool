L1 0 1 Symbolic
R1 1 2 Symbolic
C1 2 3 Symbolic
C2 3 0 Symbolic
V1 3 0 Symbolic
