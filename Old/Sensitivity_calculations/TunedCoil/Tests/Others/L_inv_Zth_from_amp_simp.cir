R1 0 1 Symbolic
L1 1 2 Symbolic
C2 2 0 Symbolic
V1 2 0 Symbolic
