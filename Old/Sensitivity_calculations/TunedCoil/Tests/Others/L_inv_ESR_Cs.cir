V1 0 1 Symbolic
L 1 2 Symbolic
Rs 2 3 Symbolic
Cs 3 0 Symbolic
C1 3 4 Symbolic
R_c1 4 5 Symbolic
R_c2 5 6 Symbolic
C2 6 0 Symbolic
Ca 5 0 Symbolic
Ra 5 0 Symbolic
